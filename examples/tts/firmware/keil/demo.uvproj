# Keil uVision project demo.uvproj, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: ING91600 INGCHIPS
  cpu: CLOCK(128000000) CPUTYPE("Cortex-M4") FPU2 ELITTLE IROM(0x2000000-0x2200000) IRAM(0x20000000-0x20008000)
  output: demo +hex
  AfterMake: fromelf.exe --bin -o demo.bin ./output/demo.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: sdk/bundles/mini/inc;sdk/bundles/mini/inc/os;sdk/src/BSP;sdk/src/FWlib;sdk/src/StartUP/ing916;sdk/src/Tools;sdk/src;..\..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x202a000 size 0x56000
  memory RVCT9: RAM 0x20007228 size 0x6dd8
  group APP
    ./src/: main.c profile.c
    ../../../ARMClang/: ing916_libaudio.lib
  group StartUP
    ./src/: startup_ing91600.s
    sdk/bundles/mini/ING9168xx/: symdefs.m
  group FWlib
    sdk/src/FWlib/: peripheral_pinctrl.c peripheral_ssp.c peripheral_uart.c
    ./sdk/src/FWlib/: peripheral_sysctrl.c

# Keil uVision project demo.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: ING91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff) CPUTYPE("Cortex-M4") FPU2 CLOCK(12800000) ELITTLE
  output: demo +hex
  AfterMake: fromelf.exe --bin -o demo.bin ./output/demo.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: sdk/bundles/mini/inc;sdk/bundles/mini/inc/os;sdk/src/BSP;sdk/src/FWlib;sdk/src/StartUP/ing916;sdk/src/Tools;sdk/src;..\..\..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x202a000 size 0x56000
  memory RVCT9: RAM 0x20007228 size 0x6dd8
  group APP
    ./src/: main.c profile.c
    ../../../../ARMClang/: ing916_libaudio_f.lib
  group StartUP
    ./src/: startup_ing91600.s
    sdk/bundles/mini/ING9168xx/: symdefs.m
  group FWlib
    sdk/src/FWlib/: peripheral_pinctrl.c peripheral_ssp.c peripheral_uart.c
    ./sdk/src/FWlib/: peripheral_sysctrl.c peripheral_i2s.c peripheral_dma.c peripheral_pwm.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.15.0
